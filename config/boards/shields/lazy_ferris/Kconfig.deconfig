## config/boards/shields/lazy_ferris/Kconfig.deconfig
```kconfig
if SHIELD_LAZY_FERRIS_LEFT || SHIELD_LAZY_FERRIS_RIGHT

config ZMK_KEYBOARD_NAME
	default "Lazy Ferris"

endif
```
